# Keil uVision project GS-A3_LKDLST_JFK_ST.uvproj, settings and files
target TI-Board (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F417ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: aufgabeGS03
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: TI_BRD_LIB\Library; .\TI_BRD_LIB\TI-C_Board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Library
    TI_BRD_LIB/Library/: assert.c tft.c TI_Lib.c TI_memory_map.h
    ./TI_BRD_LIB/Library/: keypad.c timer.c
  group TI-C_Board
    TI_BRD_LIB/TI-C_Board/: misc.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_gpio.c startup_stm32f4xx.s system_stm32f4xx.c Retarget.c Usart.c TI_Board_ADC.c TI_Board_IO.c
    ./TI_BRD_LIB/TI-C_Board/: TI_Board_IO_asm.s
    ../TI_BRD/TI_BRD_LIB/TI-C_Board/: misc.h stm32f4xx.h stm32f4xx_adc.h stm32f4xx_conf.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_rcc.h stm32f4xx_usart.h TI_Board_ADC.h TI_Board_IO.h usart.h
  group Simulated_Board
    TI_BRD_LIB/Simulated_Board/: system_stm32f10x.c startup_stm32f10x_md.s stm32f10x.h Serial.c Retarget.c Getline.c SIM_Board_IO.c
    ./TI_BRD_LIB/Simulated_Board/: SIM_Board_IO_asm.s
  group Simulation
    ./TI_BRD_LIB/Simulation/: SIMmain.ini gtpSIM.ini gtpStoppuhrSIM.ini gspSIM.ini calcSIM.ini drehgeberSIM.ini 1wireSIM.ini rmppSIM.ini rmppAdcSIM.ini reaktionSIM.ini adcHelper.ini displaySIM.ini buttonSIM.ini gpioHelper.ini deleteGpioHelper.ini gpioHelperForOneWire.ini keypadSIM.ini led.ini oneWireSTIM.ini rotarySIM.ini timer2SIM.ini userSIM.ini
  group USER
    ./: main.c linkedlist.c
  group USER Assembler
    ./: main.s
  group HEADER
    ./TI_BRD_LIB/Library/: keypad.h tft.h timer.h
    ./: stringsort.h linkedlist.h
target TI-Board Assembler (ARM-ADS)
  device: STM32F417ZG STMicroelectronics
  cpu: as above
  output: aufgabeGS03
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: TI_BRD_LIB\Library; .\TI_BRD_LIB\TI-C_Board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Simulation (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: aufgabeGS03
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SIMULATION STM32F10X_HD
  c include: .\TI_BRD_LIB\Library; .\TI_BRD_LIB\Simulated_Board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target Simulation Assembler (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  cpu: as above
  output: aufgabeGS03
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SIMULATION STM32F10X_HD
  c include: .\TI_BRD_LIB\Library; .\TI_BRD_LIB\Simulated_Board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
